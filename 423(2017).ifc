Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-06T12:44:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 06 12:44:36 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{A0D8DDA5-A789-44DD-ABA0-A6EECB91B84D}\ifc * Database version: 5507 * Database creation date: Fri Sep 06 12:44:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 06 12:44:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 06 12:44:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 423 Shower set, 423(2017):423 Shower set:441842
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 125.868 mm; NominalHeight: 760 mm; NominalWidth: 257.17 mm; Pipe Length: 720 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 423(2017); ConvergoRefNr: 0087-1909-0106-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 24/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150080487; LVI Number: 6510223; NRF Number: 4205152; RSK Number: 8320157; VVS Number: 737596434
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/423; Catalog Drawing URL: http://static.oras.com/catdrw/423; Dimension Drawing URL: http://static.oras.com/dimdrw/423; FDV Document URL: http://www.oras.com/datasheet/423/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/423; Group: Hand showers and shower sets; Long Marketing: Oras Hydractiva shower set including hand shower, adjustable max 740 mm shower rail, soap tray, wall bracket and 1750 mm shower hose. Hand shower with 3 spray modes: Sensitive (large & gently), Intense (powerful) and Pulse (massage). With limescale protection tecnology. Max. flow rate 15 l/min (3 bar). Light grey spray face, shower head size 120 mm.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 423 Shower set; Name_en: 423 Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 782 x 156 x 74; Package Weight: 1.530 kg; Product Code: 423; Product Datasheet: http://www.oras.com/datasheet/423/en; Product Family: Oras Hydractiva; Product Image URL: http://static.oras.com/image/423; Product URL: http://static.oras.com/423; Type Name: 423 Shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.00882867 m3/s; Hand Shower Size: Ø 120 mm; Installation and Maintenance: http://static.oras.com/manual/423; Installation Type: Wall-mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower holder;Shower rail;Hand shower;Shower Hose (1750 mm); Shower Spray: 3 spray; Shower Spray Number: Sensitive;Intense;Massage
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: 1462; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 423(2017); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 423; Name: 423 Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 260x125x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 423; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 423 Shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.323535 m2; Volume: 0.0245958 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 423(2017): 423 Shower set; Family and Type: 423(2017): 423 Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 423(2017): 423 Shower set; Type Id: 423(2017): 423 Shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
